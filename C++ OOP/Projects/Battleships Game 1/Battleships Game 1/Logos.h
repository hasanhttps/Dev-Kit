#pragma once

void logo() {
	char** labelDesign_italic = new char* [] {
		new char[] {"  ______      ______      ______      ______      __        ______      ______      __  __      __      ______"},
			new char[] {" /\\  == \\    /\\  __ \\    /\\__  _\\    /\\__  _\\    /\\ \\      /\\  ___\\    /\\  ___\\    /\\ \\_\\ \\    /\\_\\    /\\  == )"},
			new char[] {" \\ \\  __<    \\ \\  __ \\   \\/_/\\ \\/    \\/_/\\ \\/    \\ \\ \\____ \\ \\  __\\    \\ \\___  \\   \\ \\  __ \\   \\ \\ \\   \\ \\ \\-"},
			new char[] {"  \\ \\_____\\   \\ \\_\\ \\_\\     \\ \\_\\       \\ \\_\\     \\ \\_____\\ \\ \\_____\\   \\ \\_____\\   \\ \\_\\ \\_\\   \\ \\_\\   \\ \\ \\"},
			new char[] {"   \\/_____/    \\/_/ /_/      \\/_/        \\/_/      \\/_____/  \\/_____/    \\/_____/    \\/_/\\/_/    \\/_/    \\/_/"}
	};
	char* labelDesign_blackie = new char [] {
		R"(
			__________         __    __  .__                .__    .__              
			\______   \_____ _/  |__/  |_|  |   ____   _____|  |__ |__|_____  ______
			 |    |  _/\__  \\   __\   __\  | _/ __ \ /  ___/  |  \|  \____ \/  ___/
			 |    |   \ / __ \|  |  |  | |  |_\  ___/ \___ \|   Y  \  |  |_> >___ \ 
			 |______  /(____  /__|  |__| |____/\___  >____  >___|  /__|   __/____  >
				\/      \/                     \/     \/     \/   |__|       \/
		)"};
	char* labelDesign_x992 = new char [] {
		R"(			
					 ...     ..                       s         s          ..               .x+=:.                  .                     .x+=:.   
				  .=*8888x <"?88h.                   :8        :8    x .d88"               z`    ^%    .uef^"      @88>                  z`    ^%  
				 X>  '8888H> '8888                  .88       .88     5888R                   .   <k :d88E         %8P    .d``              .   <k 
				'88h. `8888   8888         u       :888ooo   :888ooo  '888R        .u       .@8Ned8" `888E          .     @8Ne.   .u      .@8Ned8" 
				'8888 '8888    "88>     us888u.  -*8888888 -*8888888   888R     ud8888.   .@^%8888"   888E .z8k   .@88u   %8888:u@88N   .@^%8888"  
				 `888 '8888.xH888x.  .@88 "8888"   8888      8888      888R   :888'8888. x88:  `)8b.  888E~?888L ''888E`   `888I  888. x88:  `)8b. 
				   X" :88*~  `*8888> 9888  9888    8888      8888      888R   d888 '88%" 8888N=*8888  888E  888E   888E     888I  888I 8888N=*8888 
				 ~"   !"`      "888> 9888  9888    8888      8888      888R   8888.+"     %8"    R88  888E  888E   888E     888I  888I  %8"    R88 
				  .H8888h.      ?88  9888  9888   .8888Lu=  .8888Lu=   888R   8888L        @8Wou 9%   888E  888E   888E   uW888L  888'   @8Wou 9%  
				 :"^"88888h.    '!   9888  9888   ^%888*    ^%888*    .888B . '8888c. .+ .888888P`    888E  888E   888&  '*88888Nu88P  .888888P`   
				 ^    "88888hx.+"    "888*""888"    'Y"       'Y"     ^*888%   "88888%   `   ^"F     m888N= 888>   R888" ~ '88888F`    `   ^"F     
						^"**""        ^Y"   ^Y'                         "%       "YP'                 `Y"   888     ""      888 ^                  
																										   J88"             *8E                    
																										   @%               '8>                    
																										 :"                  "                    
		)"
	};
	char* labelDesign_Slant = new char[] {
		R"(
		__/\\\\\\\\\\\\\_______________________________________________/\\\\\\_________________________________/\\\__________________________________________        
		 _\/\\\/////////\\\____________________________________________\////\\\________________________________\/\\\__________________________________________       
		  _\/\\\_______\/\\\____________________/\\\__________/\\\_________\/\\\________________________________\/\\\__________/\\\___/\\\\\\\\\_______________      
		   _\/\\\\\\\\\\\\\\___/\\\\\\\\\_____/\\\\\\\\\\\__/\\\\\\\\\\\____\/\\\________/\\\\\\\\___/\\\\\\\\\\_\/\\\_________\///___/\\\/////\\\__/\\\\\\\\\\_     
		    _\/\\\/////////\\\_\////////\\\___\////\\\////__\////\\\////_____\/\\\______/\\\/////\\\_\/\\\//////__\/\\\\\\\\\\___/\\\_\/\\\\\\\\\\__\/\\\//////__    
		     _\/\\\_______\/\\\___/\\\\\\\\\\_____\/\\\_________\/\\\_________\/\\\_____/\\\\\\\\\\\__\/\\\\\\\\\\_\/\\\/////\\\_\/\\\_\/\\\//////___\/\\\\\\\\\\_   
		      _\/\\\_______\/\\\__/\\\/////\\\_____\/\\\_/\\_____\/\\\_/\\_____\/\\\____\//\\///////___\////////\\\_\/\\\___\/\\\_\/\\\_\/\\\_________\////////\\\_  
		       _\/\\\\\\\\\\\\\/__\//\\\\\\\\/\\____\//\\\\\______\//\\\\\____/\\\\\\\\\__\//\\\\\\\\\\__/\\\\\\\\\\_\/\\\___\/\\\_\/\\\_\/\\\__________/\\\\\\\\\\_ 
		        _\/////////////_____\////////\//______\/////________\/////____\/////////____\//////////__\//////////__\///____\///__\///__\///__________\//////////__
		)"
	};
	color(logogcolor);
	if (logoC == 0) for (int i = 0; i < 5; i++) cout << labelDesign_italic[i] << endl;
	else if (logoC == 1) for (int i = 0; labelDesign_blackie[i] != '\0'; i++) cout << labelDesign_blackie[i];
	else if (logoC == 2) for (int i = 0; labelDesign_x992[i] != '\0'; i++) cout << labelDesign_x992[i];
	else if (logoC == 3) for (int i = 0; labelDesign_Slant[i] != '\0'; i++) {
		if (labelDesign_Slant[i] == '/' || labelDesign_Slant[i] == '\\') {
			color(logogcolor);
			cout << labelDesign_Slant[i];
			color(defColor);
		}
		else cout << labelDesign_Slant[i];
	}
	color(defColor);
	delete[] labelDesign_italic;

}